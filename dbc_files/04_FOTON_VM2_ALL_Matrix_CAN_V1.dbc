VERSION "created by canmatrix" NS_ : BS_: BU_: GW BO_ 288 EMS_3: 8 GW SG_ EMS3_F_EngineSpeed : 14|1@0+ (1,0) [0|1] "" Vector__XXX SG_ EMS3_N_EngineSpeed : 39|16@0+ (0.25,0) [0|16383.75] "rpm" Vector__XXX BO_ 304 Brake_1: 8 GW SG_ BR1_F_VehicleSpeed : 39|1@0+ (1,0) [0|1] "" Vector__XXX SG_ BR1_N_VehicleSpeed : 38|15@0+ (0.01,0) [0|327.66] "km/h" Vector__XXX BO_ 358 PEPS_1: 8 GW SG_ PEPS1_St_RemoteControlSt : 61|1@0+ (1,0) [0|1] "" Vector__XXX BO_ 800 EMS_2: 8 GW SG_ EMS2_F_EngineTemp : 15|1@0+ (1,0) [0|1] "" Vector__XXX SG_ EMS2_N_EngineTemp : 23|8@0+ (0.75,-48) [-48|142.5] "" Vector__XXX SG_ EMS2_St_ACON : 13|1@0+ (1,0) [0|1] "" Vector__XXX BO_ 802 EMS_11: 8 GW SG_ EMS11_N_SoakTime : 23|16@0+ (1,0) [0|2047] "minute" Vector__XXX BO_ 806 TCM_1: 8 GW SG_ TCM1_F_SLPFlag : 24|1@0+ (1,0) [0|1] "" Vector__XXX SG_ TCM1_N_SLP : 23|4@0+ (1,0) [0|15] "" Vector__XXX BO_ 839 AUDIO_7: 8 GW SG_ AUDIO7_S_ACCompresSwitchVoiceCon : 35|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AUDIO7_S_AirCirculateVoiceContro : 33|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AUDIO7_S_AirInQDetectionVoiceCon : 26|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AUDIO7_S_AutoVoiceControl : 30|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AUDIO7_S_CLMWorkVoiceControl : 37|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AUDIO7_S_FrontDefrostVoiceContro : 28|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AUDIO7_S_RearDefrostVoiceControl : 49|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AUDIO7_S_SYNC : 39|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AUDIO7_St_BlowerSpdSetVoiceContr : 43|4@0+ (1,0) [0|15] "" Vector__XXX SG_ AUDIO7_St_ControlModeManualorVoi : 38|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO7_St_FlowModeVoiceControl : 18|3@0+ (1,0) [0|7] "" Vector__XXX SG_ AUDIO7_St_SetTempVoiceControl_L : 23|5@0+ (0.5,18) [18|32] "" Vector__XXX SG_ AUDIO7_St_SetTempVoiceControl_R : 54|5@0+ (0.5,18) [18|32] "" Vector__XXX BO_ 867 BCM_1: 8 GW SG_ BCM1_AirInQLevel : 53|3@0+ (1,0) [0|7] "" Vector__XXX SG_ BCM1_F_ReverseGear : 37|1@0+ (1,0) [0|1] "" Vector__XXX SG_ BCM1_N_PM25Value : 49|10@0+ (1,0) [0|999] "ug/m^3" Vector__XXX SG_ BCM1_PM25WorkSts : 55|2@0+ (1,0) [0|3] "" Vector__XXX SG_ BCM1_St_ReverseGear : 36|1@0+ (1,0) [0|1] "" Vector__XXX BO_ 876 AC_1: 8 GW SG_ AC1_Checksum : 7|8@0+ (1,0) [0|255] "" Vector__XXX SG_ AC1_Configure : 13|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AC1_H_L_PRESS_Sta : 41|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AC1_MID_PRESS_Status : 55|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC1_RollingCounter : 11|4@0+ (1,0) [0|15] "" Vector__XXX SG_ AC1_S_AC : 15|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC1_St_AirCirculate : 52|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AC1_St_Blower : 35|4@0+ (1,0) [0|15] "" Vector__XXX SG_ AC1_St_CompresReq : 14|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC1_St_FlowMode : 58|3@0+ (1,0) [0|7] "" Vector__XXX BO_ 884 AUDIO_4: 8 GW SG_ AUDIO4_S_ACCompresSwitch : 45|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_AirCirculate : 43|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_AirFlowMode : 63|3@0+ (1,0) [0|7] "" Vector__XXX SG_ AUDIO4_S_AirInQDetection : 24|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_Auto : 42|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_BlowerSpdDown : 33|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_BlowerSpdUp : 32|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_CLMOFF : 46|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_CLM_SingleOrDouble : 55|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_FRMPositionSet : 54|4@0+ (1,0) [0|15] "" Vector__XXX SG_ AUDIO4_S_FRMSw : 31|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AUDIO4_S_FRMconcentration : 39|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AUDIO4_S_FrontDefrost : 40|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_NegativeIon : 41|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_PM25AirClean : 13|2@0+ (1,0) [0|3] "" Vector__XXX SG_ AUDIO4_S_RearDefrost : 50|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_SYNC : 18|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_SetTempDown_L : 17|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_SetTempDown_R : 15|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_SetTempUp_L : 16|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_SetTempUp_R : 14|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AUDIO4_S_TempLevelElectricAC : 29|5@0+ (1,0) [0|16] "" Vector__XXX SG_ AUDIO4_St_SetBlower : 37|4@0+ (1,0) [0|15] "" Vector__XXX SG_ AUDIO4_St_SetTemp_L : 23|5@0+ (0.5,18) [18|32] "" Vector__XXX SG_ AUDIO4_St_SetTemp_R : 60|5@0+ (0.5,18) [18|32] "" Vector__XXX BO_ 1132 AC_2: 8 GW SG_ AC2_Checksum : 7|8@0+ (1,0) [0|255] "" Vector__XXX SG_ AC2_F_EnvironmentTemp : 34|3@0+ (1,0) [0|7] "" Vector__XXX SG_ AC2_N_EnvironmentTemp : 31|8@0+ (0.5,-50) [-50|77] "" Vector__XXX SG_ AC2_N_InsideCarTemp : 23|8@0+ (0.5,-50) [-50|77] "" Vector__XXX SG_ AC2_RollingCounter : 11|4@0+ (1,0) [0|15] "" Vector__XXX SG_ AC2_St_ACSystem : 14|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC2_St_AllowStop : 45|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC2_St_Auto : 13|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC2_St_DTCFlag : 38|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC2_St_FLSeatHeating : 58|3@0+ (1,0) [0|7] "" Vector__XXX SG_ AC2_St_FRSeatHeating : 62|3@0+ (1,0) [0|7] "" Vector__XXX SG_ AC2_St_FrontDefrost : 12|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC2_St_RearDefrost : 46|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC2_St_RemoteControl : 63|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC2_St_RequestStart : 47|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC2_St_SetTempAutomaticAC_L : 44|5@0+ (0.5,18) [18|32] "" Vector__XXX SG_ AC2_St_SetTempAutomaticAC_R : 60|5@0+ (0.5,18) [18|32] "" Vector__XXX SG_ AC2_St_TempLevelElectricAC : 52|5@0+ (1,0) [0|16] "" Vector__XXX BO_ 1144 TBOX_1: 8 GW SG_ TBOX1_St_ACSetTemp : 39|5@0+ (0.5,18) [18|32] "" Vector__XXX SG_ TBOX1_St_CLM : 17|2@0+ (1,0) [0|2] "" Vector__XXX SG_ TBOX1_St_FrontDefrost : 13|2@0+ (1,0) [0|3] "" Vector__XXX BO_ 1376 EMS13: 8 GW SG_ AmbientAirTemp : 55|16@0+ (0.03125,-273) [-273|1734.96875] "deg C" Vector__XXX BO_ 1404 AC_4: 8 GW SG_ AC4_Checksum : 7|8@0+ (1,0) [0|255] "" Vector__XXX SG_ AC4_Front_EVAP_Temp : 47|11@0+ (1,-40) [-40|80] "" Vector__XXX SG_ AC4_Front_EVAP_Valid : 52|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC4_RearAirConditioningColdAir_S0 : 49|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC4_RearAirConditioningColdAir_S1 : 48|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC4_RearAirConditioningHeatingAi0 : 50|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC4_RearAirConditioningHeatingAi1 : 51|1@0+ (1,0) [0|1] "" Vector__XXX SG_ AC4_RollingCounter : 11|4@0+ (1,0) [0|15] "" Vector__XXX CM_ SG_ 288 EMS3_F_EngineSpeed "תٴ״̬"; CM_ SG_ 288 EMS3_N_EngineSpeed "ת"; CM_ SG_ 304 BR1_F_VehicleSpeed "ٱ־λ"; CM_ SG_ 304 BR1_N_VehicleSpeed ""; CM_ SG_ 358 PEPS1_St_RemoteControlSt "Զ̿źţVM2Ԥźŷ0"; CM_ SG_ 800 EMS2_F_EngineTemp "ȴˮ´״̬"; CM_ SG_ 800 EMS2_N_EngineTemp "ȴҺ¶"; CM_ SG_ 800 EMS2_St_ACON "յѹ״̬綯յ"; CM_ SG_ 802 EMS11_N_SoakTime "һεKL15µ翪ʼʱһɹֹͣʱʱsoaktimeһֱۼӣڷɹֵۼҲ㣬һֱֵǰֱֵٴ KL15µֵȻۼ"; CM_ SG_ 806 TCM1_F_SLPFlag "λϢЧ־"; CM_ SG_ 806 TCM1_N_SLP "λϢ"; CM_ SG_ 839 AUDIO7_S_ACCompresSwitchVoiceCon "AC"; CM_ SG_ 839 AUDIO7_S_AirCirculateVoiceContro "ѭ"; CM_ SG_ 839 AUDIO7_S_AirInQDetectionVoiceCon "PM2.5⹦ܼť"; CM_ SG_ 839 AUDIO7_S_AutoVoiceControl "Զյ"; CM_ SG_ 839 AUDIO7_S_CLMWorkVoiceControl "յرտ"; CM_ SG_ 839 AUDIO7_S_FrontDefrostVoiceContro "ǰ˪"; CM_ SG_ 839 AUDIO7_S_RearDefrostVoiceControl "˪"; CM_ SG_ 839 AUDIO7_S_SYNC "ͬ"; CM_ SG_ 839 AUDIO7_St_BlowerSpdSetVoiceContr "ķתٵ"; CM_ SG_ 839 AUDIO7_St_ControlModeManualorVoi ""; CM_ SG_ 839 AUDIO7_St_FlowModeVoiceControl "ģʽ 綯յ"; CM_ SG_ 839 AUDIO7_St_SetTempVoiceControl_L "¶_綯յҲҪ (غʹƽ̨λ÷ͣҶ棬񣬵ֻ࿪)"; CM_ SG_ 839 AUDIO7_St_SetTempVoiceControl_R "¶_Ҳ綯յա (غʹƽ̨λ÷ͣҶ棬񣬵ֻ࿪) VM2Ԥ"; CM_ SG_ 867 BCM1_AirInQLevel "PM2.5ȼ 綯յ"; CM_ SG_ 867 BCM1_F_ReverseGear "Чλ MTATҪ(MTӦӲߣATźӳ)"; CM_ SG_ 867 BCM1_N_PM25Value "PM2.5Ũ 綯յ"; CM_ SG_ 867 BCM1_PM25WorkSts "PM2.5ϵͳϻLINͨѶϴźŶInvalidֵ"; CM_ SG_ 867 BCM1_St_ReverseGear " MTATҪ(MTӦӲߣATźӳ)"; CM_ SG_ 876 AC1_Checksum "Checksum"; CM_ SG_ 876 AC1_Configure "յϵͳ״̬綯Զ"; CM_ SG_ 876 AC1_H_L_PRESS_Sta "ߵѹ״̬"; CM_ SG_ 876 AC1_MID_PRESS_Status "ѹѹ״̬"; CM_ SG_ 876 AC1_RollingCounter "RollingCounter"; CM_ SG_ 876 AC1_S_AC "AC״̬"; CM_ SG_ 876 AC1_St_AirCirculate "ѭ"; CM_ SG_ 876 AC1_St_Blower "λ"; CM_ SG_ 876 AC1_St_CompresReq "յѹ"; CM_ SG_ 876 AC1_St_FlowMode "ģʽ"; CM_ SG_ 884 AUDIO4_S_ACCompresSwitch "AC"; CM_ SG_ 884 AUDIO4_S_AirCirculate "ѭ"; CM_ SG_ 884 AUDIO4_S_AirFlowMode "ģʽ P4Ϊ4 5"; CM_ SG_ 884 AUDIO4_S_AirInQDetection "PM2.5⹦ܼť"; CM_ SG_ 884 AUDIO4_S_Auto "Զյ"; CM_ SG_ 884 AUDIO4_S_BlowerSpdDown "ķת½ °ť1Σɿ0𳤶̰һֱ0"; CM_ SG_ 884 AUDIO4_S_BlowerSpdUp "ķת °ť1Σɿ0𳤶̰һֱ0"; CM_ SG_ 884 AUDIO4_S_CLMOFF "յرտ"; CM_ SG_ 884 AUDIO4_S_CLM_SingleOrDouble "˫յ"; CM_ SG_ 884 AUDIO4_S_FRMPositionSet "λ"; CM_ SG_ 884 AUDIO4_S_FRMSw "յĿ"; CM_ SG_ 884 AUDIO4_S_FRMconcentration "ζŨ"; CM_ SG_ 884 AUDIO4_S_FrontDefrost "ǰ˪"; CM_ SG_ 884 AUDIO4_S_NegativeIon "ӵĿ"; CM_ SG_ 884 AUDIO4_S_RearDefrost "˪"; CM_ SG_ 884 AUDIO4_S_SYNC "ͬ °ť1ɿ0 VM2Ԥ"; CM_ SG_ 884 AUDIO4_S_SetTempDown_L "¶½ °ť1Σɿ0𳤶̰һֱ0"; CM_ SG_ 884 AUDIO4_S_SetTempDown_R "¶½ °ť1Σɿ0𳤶̰һֱ0 VM2Ԥ"; CM_ SG_ 884 AUDIO4_S_SetTempUp_L "¶ °ť1Σɿ0𳤶̰һֱ0"; CM_ SG_ 884 AUDIO4_S_SetTempUp_R "¶ °ť1Σɿ0𳤶̰һֱ0 VM2Ԥ"; CM_ SG_ 884 AUDIO4_S_TempLevelElectricAC "¶ȵλ (ֻе綯յ) VM2Ԥ"; CM_ SG_ 884 AUDIO4_St_SetBlower "λ"; CM_ SG_ 884 AUDIO4_St_SetTemp_L "¶_綯յ (غʹƽ̨λ÷ͣҶ棬񣬵ֻ࿪) VM2:ֻԶյǰյ¶"; CM_ SG_ 884 AUDIO4_St_SetTemp_R "¶_Ҳ綯յա (غʹƽ̨λ÷ͣҶ棬񣬵ֻ࿪)"; CM_ SG_ 1132 AC2_Checksum "Checksum"; CM_ SG_ 1132 AC2_F_EnvironmentTemp "¶ȴźţյһֱ0x3:Valid value"; CM_ SG_ 1132 AC2_N_EnvironmentTemp "¶ 綯/Զյܷͳ綯"; CM_ SG_ 1132 AC2_N_InsideCarTemp "¶"; CM_ SG_ 1132 AC2_RollingCounter "RollingCounter"; CM_ SG_ 1132 AC2_St_ACSystem "״̬ON/OFF"; CM_ SG_ 1132 AC2_St_AllowStop "running to stop"; CM_ SG_ 1132 AC2_St_Auto "Զģʽ 綯յ"; CM_ SG_ 1132 AC2_St_DTCFlag "ǰDTC"; CM_ SG_ 1132 AC2_St_FLSeatHeating "ǰμ״̬"; CM_ SG_ 1132 AC2_St_FRSeatHeating "ǰμ״̬"; CM_ SG_ 1132 AC2_St_FrontDefrost "ǰ˪"; CM_ SG_ 1132 AC2_St_RearDefrost "˪"; CM_ SG_ 1132 AC2_St_RemoteControl "յɹյTBOXԶյ յԶˮ²յʱźֵ1 VM2:Ԥź"; CM_ SG_ 1132 AC2_St_RequestStart "󷢶stop to running"; CM_ SG_ 1132 AC2_St_SetTempAutomaticAC_L "¶_綯յ (غʹƽ̨λ÷ͣҶ棬񣬵ֻ࿪)"; CM_ SG_ 1132 AC2_St_SetTempAutomaticAC_R "¶_Ҳ綯յ (غʹƽ̨λ÷ͣҶ棬񣬵ֻ࿪) VM2:ƣ˫ԤźԤ"; CM_ SG_ 1132 AC2_St_TempLevelElectricAC "¶ȵλ (綯յ¶ȵλźţԵ綯յԲ)"; CM_ SG_ 1144 TBOX1_St_ACSetTemp "Զ̿յãVM2Ԥ"; CM_ SG_ 1144 TBOX1_St_CLM "Զ̿ƿյVM2Ԥ"; CM_ SG_ 1376 AmbientAirTemp "ݲǿƲɼ"; CM_ SG_ 1404 AC4_Checksum "Checksum"; CM_ SG_ 1404 AC4_RollingCounter "RollingCounter"; BA_DEF_ BO_ "GenMsgCycleTime" INT 0 65535; BA_DEF_ SG_ "GenSigStartValue" FLOAT 0 100000000000; BA_DEF_ SG_ "SystemSignalLongSymbol" STRING; BA_ "GenMsgCycleTime" BO_ 358 20; BA_ "GenMsgCycleTime" BO_ 839 20; BA_ "SystemSignalLongSymbol" SG_ 839 AUDIO7_S_ACCompresSwitchVoiceCon "AUDIO7_S_ACCompresSwitchVoiceControl"; BA_ "SystemSignalLongSymbol" SG_ 839 AUDIO7_S_AirCirculateVoiceContro "AUDIO7_S_AirCirculateVoiceControl"; BA_ "SystemSignalLongSymbol" SG_ 839 AUDIO7_S_AirInQDetectionVoiceCon "AUDIO7_S_AirInQDetectionVoiceControl"; BA_ "SystemSignalLongSymbol" SG_ 839 AUDIO7_S_FrontDefrostVoiceContro "AUDIO7_S_FrontDefrostVoiceControl"; BA_ "SystemSignalLongSymbol" SG_ 839 AUDIO7_St_BlowerSpdSetVoiceContr "AUDIO7_St_BlowerSpdSetVoiceControl"; BA_ "SystemSignalLongSymbol" SG_ 839 AUDIO7_St_ControlModeManualorVoi "AUDIO7_St_ControlModeManualorVoice"; BA_ "SystemSignalLongSymbol" SG_ 1404 AC4_RearAirConditioningColdAir_S0 "AC4_RearAirConditioningColdAir_Status"; BA_ "SystemSignalLongSymbol" SG_ 1404 AC4_RearAirConditioningColdAir_S1 "AC4_RearAirConditioningColdAir_Switch"; BA_ "SystemSignalLongSymbol" SG_ 1404 AC4_RearAirConditioningHeatingAi0 "AC4_RearAirConditioningHeatingAir_Status"; BA_ "SystemSignalLongSymbol" SG_ 1404 AC4_RearAirConditioningHeatingAi1 "AC4_RearAirConditioningHeatingAir_Switch"; VAL_ 288 EMS3_F_EngineSpeed 0 "Ч" 1 "Ч"; VAL_ 304 BR1_F_VehicleSpeed 0 "Ч" 1 "Ч"; VAL_ 304 BR1_N_VehicleSpeed 32767 "Ч"; VAL_ 358 PEPS1_St_RemoteControlSt 0 "Not Remote control mode" 1 "Remote control mode"; VAL_ 800 EMS2_F_EngineTemp 0 "Ч" 1 "Ч"; VAL_ 800 EMS2_St_ACON 0 "AC compressor relay off" 1 "AC compressor relay on"; VAL_ 806 TCM1_F_SLPFlag 0 "Ч" 1 "Ч"; VAL_ 806 TCM1_N_SLP 0 "Undefined position" 1 "P(Park)" 2 "R(Reverse)" 3 "N(Neutral)" 4 "D(Drive)" 5 "S(Sport)" 6 "M(Manual)" 15 "error"; VAL_ 839 AUDIO7_S_ACCompresSwitchVoiceCon 0 "Off" 1 "On" 3 "invalid(No Voice cmd)"; VAL_ 839 AUDIO7_S_AirCirculateVoiceContro 0 "Fresh air" 1 "Circulate air" 3 "invalid(No Voice cmd)"; VAL_ 839 AUDIO7_S_AirInQDetectionVoiceCon 0 "Off" 1 "On" 3 "invalid(No Voice cmd)"; VAL_ 839 AUDIO7_S_AutoVoiceControl 0 "Off" 1 "On" 3 "invalid(No Voice cmd)"; VAL_ 839 AUDIO7_S_CLMWorkVoiceControl 0 "Off" 1 "On" 3 "invalid(No Voice cmd)"; VAL_ 839 AUDIO7_S_FrontDefrostVoiceContro 0 "Off" 1 "On" 3 "invalid(No Voice cmd)"; VAL_ 839 AUDIO7_S_RearDefrostVoiceControl 0 "Off" 1 "On" 3 "invalid(No Voice cmd)"; VAL_ 839 AUDIO7_S_SYNC 0 "No Command" 1 "SYNCOpen" 2 "SYNCClose" 3 ""; VAL_ 839 AUDIO7_St_BlowerSpdSetVoiceContr 0 "Reseved" 1 "level1" 2 "level2" 3 "level3" 4 "level4" 5 "level5" 6 "level6" 7 "level7" 8 "level8" 9 "Invalid(No Voice cmd)"; VAL_ 839 AUDIO7_St_ControlModeManualorVoi 0 "Manual control" 1 "Voice control"; VAL_ 839 AUDIO7_St_FlowModeVoiceControl 0 "NoCoComand" 1 "auto" 2 "only body" 3 "only foot" 4 "" 5 "window&foot" 6 "body&foot" 7 "invalid(No Voice cmd)"; VAL_ 839 AUDIO7_St_SetTempVoiceControl_L 0 "Low" 28 "Hi" 31 "No Voice cmd"; VAL_ 839 AUDIO7_St_SetTempVoiceControl_R 0 "Low" 28 "Hi" 31 "No Voice cmd"; VAL_ 867 BCM1_AirInQLevel 0 "Level 1" 1 "Level 2" 2 "Level 3" 3 "Level 4" 4 "Level 5" 5 "Level 6" 6 "not used" 7 "Ч"; VAL_ 867 BCM1_F_ReverseGear 0 "Ч" 1 "Ч"; VAL_ 867 BCM1_PM25WorkSts 0 "Standby" 1 "Running" 3 "Ч"; VAL_ 867 BCM1_St_ReverseGear 0 "δ" 1 "Ѽ"; VAL_ 876 AC1_Configure 0 "綯յ" 1 "綯˫յ" 2 "Զ˫յ" 3 "Configure Type 4Reserved"; VAL_ 876 AC1_H_L_PRESS_Sta 0 "" 1 "ѹ" 2 "ѹ"; VAL_ 876 AC1_MID_PRESS_Status 0 "պ" 1 "Ͽ"; VAL_ 876 AC1_S_AC 0 "Off" 1 "On"; VAL_ 876 AC1_St_AirCirculate 0 "Fresh air" 1 "Circulate air" 2 "AutoAQS" 3 ""; VAL_ 876 AC1_St_Blower 0 "Blower Off" 1 "level 1" 2 "level 2" 3 "level 3" 4 "level 4" 5 "level 5" 6 "level 6" 7 "level 7" 8 "level8" 9 "Auto"; VAL_ 876 AC1_St_CompresReq 0 "Not reqest" 1 "Request"; VAL_ 876 AC1_St_FlowMode 0 "auto" 1 "Defrost" 2 "only body" 3 "only foot" 4 "" 5 "window&foot" 6 "body&foot" 7 "all"; VAL_ 884 AUDIO4_S_ACCompresSwitch 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_AirCirculate 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_AirFlowMode 0 "Not Press" 1 "auto" 2 "only body" 3 "only foot" 4 "" 5 "window&foot" 6 "body&foot" 7 ""; VAL_ 884 AUDIO4_S_AirInQDetection 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_Auto 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_BlowerSpdDown 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_BlowerSpdUp 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_CLMOFF 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_CLM_SingleOrDouble 0 "յ" 1 "˫յ"; VAL_ 884 AUDIO4_S_FRMPositionSet 0 "Initial value" 1 "Fragrance Position_1 (λ1)" 2 "Fragrance Position_2 (λ2" 3 "Fragrance Position_3 (λ3"; VAL_ 884 AUDIO4_S_FRMSw 0 "No request / Initial value" 1 "Close request" 2 "Open request" 3 ""; VAL_ 884 AUDIO4_S_FRMconcentration 0 "Initial value" 1 "Low concentration" 2 "Middle concentration" 3 "High concentration"; VAL_ 884 AUDIO4_S_FrontDefrost 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_NegativeIon 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_PM25AirClean 0 "No command" 1 "No Clean" 2 "Clean" 3 ""; VAL_ 884 AUDIO4_S_RearDefrost 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_SYNC 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_SetTempDown_L 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_SetTempDown_R 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_SetTempUp_L 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_SetTempUp_R 0 "Not Press" 1 "Press"; VAL_ 884 AUDIO4_S_TempLevelElectricAC 0 "No Command" 1 "Cold level 8" 2 "Cold level 7" 3 "Cold level 6" 4 "Cold level 5" 5 "Cold level 4" 6 "Cold level 3" 7 "Cold level 2" 8 "Cold level 1" 9 "Warm level 1" 10 "Warm level 2" 11 "Warm level 3" 12 "Warm level 4" 13 "Warm level 5" 14 "Warm level 6" 15 "Warm level 7" 16 "Warm level 8"; VAL_ 884 AUDIO4_St_SetBlower 0 "No Command" 1 "level 1" 2 "level 2" 3 "level 3" 4 "level 4" 5 "level 5" 6 "level 6" 7 "level 7" 8 "level8" 9 "Auto"; VAL_ 884 AUDIO4_St_SetTemp_L 0 "Low" 28 "Hi" 31 "No Command"; VAL_ 884 AUDIO4_St_SetTemp_R 0 "Low" 28 "Hi" 31 "No Command"; VAL_ 1132 AC2_F_EnvironmentTemp 0 "Broken Circuit" 1 "Short Circuit" 2 "Value Out of Range" 3 "Valid value" 7 "Ч"; VAL_ 1132 AC2_N_EnvironmentTemp 255 "Ч"; VAL_ 1132 AC2_N_InsideCarTemp 255 "Ч"; VAL_ 1132 AC2_St_ACSystem 0 "Off" 1 "On"; VAL_ 1132 AC2_St_AllowStop 0 "Not allow" 1 "Allow"; VAL_ 1132 AC2_St_Auto 0 "Off" 1 "On"; VAL_ 1132 AC2_St_DTCFlag 0 "no DTC exist" 1 "DTC exist"; VAL_ 1132 AC2_St_FLSeatHeating 0 "Off" 1 "Level 1" 2 "Level 2" 3 "Level 3"; VAL_ 1132 AC2_St_FRSeatHeating 0 "Off" 1 "Level 1" 2 "Level 2" 3 "Level 3"; VAL_ 1132 AC2_St_FrontDefrost 0 "Off" 1 "On"; VAL_ 1132 AC2_St_RearDefrost 0 "Off" 1 "On"; VAL_ 1132 AC2_St_RemoteControl 0 "Invaid" 1 "vaid"; VAL_ 1132 AC2_St_RequestStart 0 "Not Request" 1 "Request"; VAL_ 1132 AC2_St_SetTempAutomaticAC_L 0 "Low" 28 "Hi"; VAL_ 1132 AC2_St_SetTempAutomaticAC_R 0 "Low" 28 "Hi"; VAL_ 1132 AC2_St_TempLevelElectricAC 0 "Off" 1 "Cold level 8" 2 "Cold level 7" 3 "Cold level 6" 4 "Cold level 5" 5 "Cold level 4" 6 "Cold level 3" 7 "Cold level 2" 8 "Cold level 1" 9 "Warm level 1" 10 "Warm level 2" 11 "Warm level 3" 12 "Warm level 4" 13 "Warm level 5" 14 "Warm level 6" 15 "Warm level 7" 16 "Warm level 8"; VAL_ 1144 TBOX1_St_ACSetTemp 0 "Low" 28 "Hi" 29 "Auto" 31 "Ч"; VAL_ 1144 TBOX1_St_CLM 0 "CLM off" 1 "CLM on" 2 "" 3 "Ч"; VAL_ 1144 TBOX1_St_FrontDefrost 0 "off" 1 "on" 2 "" 3 "Ч"; VAL_ 1404 AC4_Front_EVAP_Valid 0 "Ч" 1 "Ч"; VAL_ 1404 AC4_RearAirConditioningColdAir_S0 0 "OFF" 1 "ON"; VAL_ 1404 AC4_RearAirConditioningColdAir_S1 0 "Not Pressed" 1 "Pressed"; VAL_ 1404 AC4_RearAirConditioningHeatingAi0 0 "OFF" 1 "ON"; VAL_ 1404 AC4_RearAirConditioningHeatingAi1 0 "Not Pressed" 1 "Pressed";